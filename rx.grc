<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sideband_rx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transistion</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/Users/majora/Documents/output.txt</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_gfsk_demod</key>
<param><key>id</key><value>digital_gfsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>9</value></param>
<param><key>sensitivity</key><value>1.0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>23000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1, samp_rate, sideband_rx,100)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>500</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>100e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_demod_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>digital_gfsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
